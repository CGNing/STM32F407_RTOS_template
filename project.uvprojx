# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\User;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\Keil\ARM_CM4F;.\My_Lib;.\Drive;.\Drive\ZE_key_led;.\Drive\tft;.\Drive\tft\24CXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c
  group FreeRTOS files
    ./FreeRTOS/: tasks.c queue.c list.c timers.c
    ./FreeRTOS/portable/Keil/ARM_CM4F/: port.c
    ./FreeRTOS/portable/Keil/MemMang/: heap_2.c
  group My_Lib
    ./My_Lib/: delay.c usart.c
  group Drive
    ./Drive/ZE_key_led/: led.c key.c
  group tft
    ./Drive/tft/: lcd.c touch.c ctiic.c ft5206.c gt9147.c ott2001a.c lcd_printf.c
    ./Drive/tft/24CXX/: 24cxx.c myiic.c
  group User
    ./User/: main.c
software components: CMSIS:CORE 5.2.0
